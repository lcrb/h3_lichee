## drivers/omega/Kconfig
```kconfig
config OMEGA_MODULE
    tristate "omega hardware support"
    default y
    help
        omega hardware support
```
